#include <stdint.h>
#include <stdlib.h>
#include <math.h>
#include "OLED.h"
#include "Key.h"
#include "cmsis_os.h"
#include "Dino.h"

#define DINO_PI    3.1415926535

/* ---------------- 图像数据 ---------------- */

const uint8_t Ground[] = {
  0x0C,0x0C,0x0C,0x0E,0x0E,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x4C,0x6C,0x2C,0x0C,0x0C,
  0x0C,0x0C,0x0C,0x0C,0x0C,0x0E,0x0C,0x0C,0x0E,0x0F,0x3E,0x2E,0x2C,0x0C,0x0C,0x0C,
  0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x2C,0x2C,0x2C,0x0C,0x0C,0x0C,0x0C,0x0E,0x0E,0x0E,
  0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x2C,0x2C,0x2C,0x0C,0x0C,0x1C,0x0C,0x0C,0x0C,
  0x0C,0x0C,0x0C,0x0D,0x0F,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x4C,0x4C,0x4C,0x8C,
  0xDC,0x0C,0x0E,0x0E,0x0E,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,
  0x0C,0x0C,0x2C,0x3C,0x2C,0x1C,0x0E,0x3C,0x3C,0x0C,0x1C,0x0C,0x0C,0x1C,0x0C,0x0C,
  0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x1C,0x0C,0x0E,0x0C,0x1C,0x7C,0x0C,0x0C,0x0C,0x0C,
  0x0C,0x1C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x3C,0x1C,0x3C,0x2C,0x2C,0x2C,0x3F,
  0x0C,0x4C,0x4C,0x4C,0x4C,0x0C,0x6C,0x4C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,
  0x0C,0x0C,0x0C,0x0C,0x0C,0x1C,0x1C,0x0C,0x0C,0x0C,0x0C,0x1C,0x4C,0x4C,0x0C,0x0C,
  0x0E,0x0E,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x2C,0x2F,0x2E,0x2E,
  0x2E,0xFC,0x3C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x2C,0x0C,0x0C,0x0D,0x0D,0x0D,0x0F,
  0x0E,0x0C,0x0C,0x0C,0x1C,0x1C,0x1C,0x1C,0x1C,0x0C,0x0C,0x0C,0x1C,0x7C,0x0C,0x0C,
  0x1C,0x1C,0x3C,0x2C,0x0C,0x2C,0x2C,0x2C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0E,0x0E,0x0E,
  0x0E,0x0E,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x4D,0x4F,0x4E,0x0E,0x0C,0x9C,0x0C,
};

const uint8_t Barrier[][48] = {
  /* 0 */
  0x00,0x00,0x00,0x00,0x00,0x00,0xF8,0xFC,0xF8,0x00,0x00,0xF0,0xF0,0x00,0x00,0x00,
  0xC0,0xC0,0xC7,0xCF,0xCC,0x0C,0xFF,0xFF,0xFF,0x03,0xC3,0xC3,0xC1,0xC0,0xC0,0xC0,
  0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x01,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  /* 1 */
  0x00,0x00,0x00,0x80,0xC0,0x00,0x00,0x00,0x78,0xE0,0xC0,0xFC,0xFC,0x00,0x00,0x00,
  0xC0,0xDC,0x18,0xFF,0xFF,0x06,0x03,0x00,0x00,0x00,0x01,0xFF,0xFF,0x0C,0xCE,0xC6,
  0x00,0x00,0x00,0x01,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x01,0x00,0x00,0x00,
  /* 2 */
  0x00,0x00,0x00,0x00,0x00,0xC0,0x00,0xFC,0xF0,0xC0,0x60,0x00,0x00,0x00,0x00,0x00,
  0xC0,0x08,0xFC,0xFE,0x30,0x18,0x01,0xFF,0xFF,0x01,0x00,0x18,0x70,0xFE,0x07,0xC0,
  0x00,0x00,0x01,0x01,0x00,0x00,0x00,0x01,0x01,0x00,0x00,0x00,0x00,0x01,0x00,0x00,
};

const uint8_t Cloud[] = {
  0x00,0x70,0x58,0x58,0x4C,0x46,0x43,0x41,0x43,0x42,0x46,0x44,0x4C,0x58,0x70,0x00,
};

const uint8_t Dino[][48] = {
  /* 0：跑步第一帧 */
  0x00,0x80,0x80,0x00,0x00,0x00,0x00,0xF8,0xFC,0xFC,0xFC,0x74,0x7C,0x78,0x70,0x00,
  0x00,0x03,0x0F,0xFE,0xFE,0x3E,0x3F,0x7F,0x7F,0x5F,0x06,0x02,0x03,0x00,0x00,0x00,
  0x00,0x00,0x00,0x01,0x01,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  /* 1：跑步第二帧 */
  0x00,0x80,0x80,0x00,0x00,0x00,0x00,0xF8,0xFC,0xFC,0xFC,0x74,0x7C,0x78,0x70,0x00,
  0x00,0x03,0x0F,0x7E,0x7E,0x5E,0x1F,0xFF,0xFF,0x1F,0x06,0x02,0x03,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x01,0x01,0x00,0x00,0x00,0x00,0x00,0x00,
  /* 2：跳跃 */
  0x00,0x80,0x80,0x00,0x00,0x00,0x00,0xF8,0xFC,0xFC,0xFC,0x74,0x7C,0x78,0x70,0x00,
  0x00,0x03,0x0F,0xFE,0xFE,0x1E,0x1F,0xFF,0xFF,0x1F,0x06,0x02,0x03,0x00,0x00,0x00,
  0x00,0x00,0x00,0x01,0x01,0x01,0x00,0x01,0x01,0x01,0x00,0x00,0x00,0x00,0x00,0x00,
};

/* ---------------- 全局变量 ---------------- */

struct Object_Position {
  uint8_t minX, minY, maxX, maxY;
};

uint16_t Ground_Pos;              /* 地面滚动偏移 */
int Score;                        /* 分数 */

uint8_t barrier_flag;             /* 当前障碍物图案 0~2 */
uint8_t Barrier_Pos;              /* 障碍物 X 偏移 */
struct Object_Position barrier;   /* 障碍物碰撞盒 */

uint8_t Cloud_Pos;                /* 云朵移动偏移 */

uint8_t dino_jump_flag = 0;       /* 0=地面，1=跳跃中 */
uint16_t jump_t;                  /* 跳跃时间计数（1ms 单位） */
uint8_t Jump_Pos;                 /* 当前跳跃高度 */
struct Object_Position dino;      /* 恐龙碰撞盒 */

static uint8_t KeyNum;
static uint8_t Dino_ExitFlag;     /* 0=继续，1=回菜单，2=回主页 */

/* ---------------- 显示函数 ---------------- */

void Show_Score(void)
{
  /* 参考工程：Line=1, Column=17, 6×8 字体 → 像素 (96, 0) */
  OLED_ShowNum(96, 0, Score, 5, OLED_6X8);
}

void Show_Ground(void)
{
  uint16_t i;

  if (Ground_Pos < 128)
  {
    for (i = 0; i < 128; i++)
    {
      OLED_DisplayBuf[7][i] = Ground[i + Ground_Pos];
    }
  }
  else
  {
    for (i = 0; i < 255 - Ground_Pos; i++)
    {
      OLED_DisplayBuf[7][i] = Ground[i + Ground_Pos];
    }
    for (i = 255 - Ground_Pos; i < 128; i++)
    {
      OLED_DisplayBuf[7][i] = Ground[i - (255 - Ground_Pos)];
    }
  }
}

void Show_Barrier(void)
{
  if (Barrier_Pos >= 143)
  {
    barrier_flag = rand() % 3;
  }

  /* 参考工程的 ShowImageWithReverse(...,1) 等价于普通显示 */
  OLED_ShowImage(127 - Barrier_Pos, 44, 16, 18, Barrier[barrier_flag]);

  barrier.minX = (127 - Barrier_Pos) + 5;
  barrier.maxX = (127 - Barrier_Pos) + 11;
  barrier.minY = 44 + 4;
  barrier.maxY = 62;
}

void Show_Cloud(void)
{
  OLED_ShowImage(127 - Cloud_Pos, 9, 16, 8, Cloud);
}

void Show_Dino(void)
{
  uint8_t current_dino_y;

  KeyNum = Key_GetNum();

  if (KeyNum == 3)
  {
    Dino_ExitFlag = 1;              /* 短按 Key3：回菜单 */
  }
  else if (KeyNum == 4)
  {
    Dino_ExitFlag = 2;              /* 长按 Key3：回主页 */
  }
  else if (KeyNum == 1 && dino_jump_flag == 0)
  {
    dino_jump_flag = 1;             /* Key1：起跳 */
  }

  if (dino_jump_flag)
  {
    Jump_Pos = 28 * sin((float)(DINO_PI * jump_t / 1000));
  }
  else
  {
    Jump_Pos = 0;
  }

  current_dino_y = 42 - Jump_Pos;

  if (dino_jump_flag == 0)
  {
    if ((Ground_Pos / 8) % 2 == 0)
      OLED_ShowImageOR(0, current_dino_y, 16, 18, Dino[0]);
    else
      OLED_ShowImageOR(0, current_dino_y, 16, 18, Dino[1]);
  }
  else
  {
    OLED_ShowImageOR(0, current_dino_y, 16, 18, Dino[2]);
  }

  dino.minX = 0 + 4;
  dino.maxX = 16 - 4;
  dino.minY = current_dino_y + 2;
  dino.maxY = current_dino_y + 18 - 2;
}

/* ---------------- 游戏逻辑 ---------------- */

/* AABB 碰撞检测 */
static int isColliding(struct Object_Position *a, struct Object_Position *b)
{
  if ((a->maxX > b->minX) &&
      (a->minX < b->maxX) &&
      (a->maxY > b->minY) &&
      (a->minY < b->maxY))
  {
    OLED_Clear();
    OLED_ShowString(24, 8, "GAME  OVER", OLED_8X16);
    OLED_Update();

    osDelay(1500);

    OLED_Clear();
    OLED_Update();
    return 1;
  }
  return 0;
}

int DinoGame_Animation(void)
{
  while (1)
  {
    OLED_Clear();

    Show_Ground();
    Show_Cloud();
    Show_Barrier();
    Show_Dino();
    Show_Score();

    OLED_Update();

    if (Dino_ExitFlag != 0)
    {
      return Dino_ExitFlag;         /* 1=回菜单，2=回主页 */
    }

    if (isColliding(&dino, &barrier))
    {
      return 0;                     /* 碰撞：游戏结束 */
    }

    osDelay(1);                     /* 让出 CPU */
  }
}

/* 每 1ms 调用一次（TIM2 中断） */
void Dino_Tick(void)
{
  static uint8_t Score_Count, Ground_Count, Cloud_Count;

  Score_Count++;
  Ground_Count++;
  Cloud_Count++;

  if (Score_Count >= 100)
  {
    Score_Count = 0;
    Score++;
  }

  if (Ground_Count >= 20)
  {
    Ground_Count = 0;
    Ground_Pos++;
    Barrier_Pos++;
    if (Ground_Pos >= 256) Ground_Pos = 0;
    if (Barrier_Pos >= 144) Barrier_Pos = 0;
  }

  if (Cloud_Count >= 50)
  {
    Cloud_Count = 0;
    Cloud_Pos++;
    if (Cloud_Pos >= 200) Cloud_Pos = 0;
  }

  if (dino_jump_flag == 1)
  {
    jump_t++;
    if (jump_t >= 1000)
    {
      jump_t = 0;
      dino_jump_flag = 0;
    }
  }
}

void DinoGame_Pos_Init(void)
{
  Score = 0;
  Ground_Pos = 0;
  Barrier_Pos = 0;
  Cloud_Pos = 0;
  Jump_Pos = 0;
  dino_jump_flag = 0;
  jump_t = 0;
  barrier_flag = 0;
  Dino_ExitFlag = 0;
}
